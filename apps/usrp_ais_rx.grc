options:
  parameters:
    author: Nick Foster
    generate_options: qt_gui
    id: usrp_ais_rx
    output_language: python
    title: USRP AIS receiver
  states: {}

blocks:
- name: gain
  id: variable_qtgui_range
  parameters:
    label: Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '120'
    value: '70'
  states: {}
- name: ted_bw
  id: variable_qtgui_range
  parameters:
    label: TED bandwidth
    orient: Qt.Horizontal
    start: '0.001'
    step: '0.001'
    stop: '1.0'
    value: '0.007'
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    label: Correlator threshold
    orient: Qt.Horizontal
    start: '0'
    step: '0.001'
    stop: '1.0'
    value: '0.83'
  states: {}
- name: ais_rx_core_0
  id: ais_rx_core
  parameters:
    bb_sps: '4'
    bt: '0.4'
    loopbw: ted_bw
    samp_rate: samp_rate
    threshold: threshold
  states: {}
- name: ais_rx_core_0_0
  id: ais_rx_core
  parameters:
    bb_sps: '4'
    bt: '0.4'
    loopbw: ted_bw
    samp_rate: samp_rate
    threshold: threshold
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: ant
  id: parameter
  parameters:
    label: Antenna
    type: str
    value: TX/RX
  states: {}
- name: args
  id: parameter
  parameters:
    label: USRP args
    type: str
    value: '""'
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    comment: A channel
    phase_inc: 2*math.pi*(-25e3/samp_rate)
  states: {}
- name: blocks_rotator_cc_0_0
  id: blocks_rotator_cc
  parameters:
    comment: B channel
    phase_inc: 2*math.pi*(25e3/samp_rate)
  states: {}
- name: gain
  id: parameter
  parameters:
    label: Gain
    type: intx
    value: '70'
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: pdu_to_nmea_0
  id: pdu_to_nmea
  parameters:
    designator: A
  states: {}
- name: pdu_to_nmea_0_0
  id: pdu_to_nmea
  parameters:
    designator: B
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"time_est"'
    type: float
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample rate
    type: eng_float
    value: 200e3
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ant
    center_freq0: 162e6
    dc_offs_enb0: '""'
    dev_args: '"args"'
    gain0: gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [ais_rx_core_0, '1', analog_quadrature_demod_cf_0, '0']
- [ais_rx_core_0, '2', qtgui_time_sink_x_0, '1']
- [ais_rx_core_0, out, pdu_to_nmea_0, print]
- [ais_rx_core_0_0, out, pdu_to_nmea_0_0, print]
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_rotator_cc_0, '0', ais_rx_core_0, '0']
- [blocks_rotator_cc_0_0, '0', ais_rx_core_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_rotator_cc_0, '0']
- [uhd_usrp_source_0, '0', blocks_rotator_cc_0_0, '0']

metadata:
  file_format: 1
